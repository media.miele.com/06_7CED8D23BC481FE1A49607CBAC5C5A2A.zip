Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 90587c84-ad19-4a2b-9e4b-687bd62d7308, NumberOfSaves: 1]
File name: 0001
Time: 2026-07-28T10:21:58+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11952970_EU1_FN4342E_WS:37434254_EU1_11952970_FN4342E_WS, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_BRWS, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Connection_Modul, <Unnamed>, z_Miele_Design_Glass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 1655 mm; Depth: 675 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 37434254_EU1_11952970_FN4342E_WS; sets with these values: 2

# IfcDistributionPort, Port_355676_1
Description: Flow; FlowDirection: SOURCEANDSINK
